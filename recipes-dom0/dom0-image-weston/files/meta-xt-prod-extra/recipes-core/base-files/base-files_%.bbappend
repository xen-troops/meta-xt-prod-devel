# Append domain name
hostname += "-dom0"
