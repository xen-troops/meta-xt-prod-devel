CORE_IMAGE_EXTRA_INSTALL += "dom0-image-weston-domu-copy-kernel"
