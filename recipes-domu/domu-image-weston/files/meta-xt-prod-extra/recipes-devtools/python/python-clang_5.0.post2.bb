inherit setuptools
require python-clang.inc
