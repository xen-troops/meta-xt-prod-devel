require gles-user-module.inc

BRANCH = "1.10/ED5187610"
SRCREV = "${AUTOREV}"
