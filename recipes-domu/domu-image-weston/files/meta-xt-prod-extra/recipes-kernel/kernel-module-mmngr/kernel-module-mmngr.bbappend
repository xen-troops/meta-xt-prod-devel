# original recipe defines MMNGR_SALVATORX for all the boards, e.g. x3ulcb
MMNGR_CFG_rcar = "MMNGR_SALVATORX"
