require linux-kernel.inc
