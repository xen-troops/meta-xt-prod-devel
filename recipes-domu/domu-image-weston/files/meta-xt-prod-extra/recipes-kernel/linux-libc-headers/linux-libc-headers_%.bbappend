RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "v4.14.75-ltsi/rcar-3.9.2"
SRCREV = "${AUTOREV}"
LINUX_VERSION = "4.14.75"
