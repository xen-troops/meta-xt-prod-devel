# libdrm
PREFERRED_VERSION_libdrm = "2.4.68"
