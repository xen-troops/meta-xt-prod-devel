RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git;protocol=https"

BRANCH = "v4.14.75-ltsi/rcar-3.9.6-xt0.1"
SRCREV = "ad0374907ee5212654837c41aebe8b04e9d79404"
LINUX_VERSION = "4.14.75"
