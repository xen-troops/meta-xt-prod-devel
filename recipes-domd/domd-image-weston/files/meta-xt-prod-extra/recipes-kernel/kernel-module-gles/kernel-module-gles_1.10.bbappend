require inc/xt_shared_env.inc

PVRKM_URL = "git://git@gitpct.epam.com/epmd-aepr/pvr_km_vgpu_img.git"
BRANCH = "1.10/ED5187610"
SRCREV = "8511498a076256fd2ac95ea2f027d4006b015dec"
