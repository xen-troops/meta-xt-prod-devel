SRC_URI_remove = "\
    file://lspci.cfg \
"
