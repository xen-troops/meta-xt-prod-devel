SRC_URI_remove = " \
    file://0001-lib-randutils.c-Fix-args-of-getrandom.patch \
"
