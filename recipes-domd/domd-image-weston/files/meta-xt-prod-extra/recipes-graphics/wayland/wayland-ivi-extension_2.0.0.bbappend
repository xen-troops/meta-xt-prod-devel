BRANCH = "2.0"
SRC_URI = "git://github.com/GENIVI/${BPN}.git;protocol=http;tag=2.2.0"
