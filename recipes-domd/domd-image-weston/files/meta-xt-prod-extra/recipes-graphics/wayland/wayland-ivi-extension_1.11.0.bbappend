SRCREV = "8fdae4cff2647d0060174509990cd2874e1d793d"
BRANCH = "1.11"
SRC_URI = "git://github.com/GENIVI/${BPN}.git;protocol=http;branch=${BRANCH}"
