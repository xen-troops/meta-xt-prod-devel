DEPENDS += " gles-module-egl-headers"
DEPENDS_remove = "gles-user-module"
