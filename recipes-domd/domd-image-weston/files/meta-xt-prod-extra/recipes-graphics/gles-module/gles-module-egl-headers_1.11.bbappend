BRANCH = "1.11/5516664_4.7.0"
SRCREV = "${AUTOREV}"
