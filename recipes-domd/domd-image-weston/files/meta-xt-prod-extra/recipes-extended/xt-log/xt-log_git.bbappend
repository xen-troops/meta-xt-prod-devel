SRC_URI = "git://github.com/xen-troops/${PN}.git;branch=master"
SRCREV = "a88163b7f64c4eec4f7362ba33ecd55bd3dd1cdb"
