
SRC_URI="https://github.com/lkundrak/dev86/archive/v${PV}.tar.gz"

SRC_URI[md5sum] = "288af53f256300777efc91d97c082fda"
SRC_URI[sha256sum] = "533f2a0d2ed61223040f27e5cd007a11d969aaf34f6b709ece122b1e6fc50580"
