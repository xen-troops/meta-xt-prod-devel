DEPENDS += " \
    libgbm \
    wayland-kms \
"
