TUNE_CCARGS := "${@oe.utils.str_filter_out('-mtune=cortex-a57.cortex-a53', '${TUNE_CCARGS}', d)}"