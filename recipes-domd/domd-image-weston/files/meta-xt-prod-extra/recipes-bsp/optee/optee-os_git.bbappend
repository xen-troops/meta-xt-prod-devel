EXTRA_OEMAKE  += " \
	       CFG_RPMB_FS=y \
	       CFG_RPMB_WRITE_KEY=y \
	       "
