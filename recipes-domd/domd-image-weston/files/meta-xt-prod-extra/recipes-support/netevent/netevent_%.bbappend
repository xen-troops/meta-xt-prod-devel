# Sometimes we observe race during multithreaded compilation
# so it's better to build netevent in one thread
PARALLEL_MAKE = ""
