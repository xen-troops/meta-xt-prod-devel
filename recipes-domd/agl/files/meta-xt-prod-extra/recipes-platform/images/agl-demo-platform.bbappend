require inc/agl-image.inc

inherit populate_sdk_qt5
