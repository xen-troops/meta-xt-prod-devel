AGL_APPS_append = " \
    aglsurfaceswitcher \
"

