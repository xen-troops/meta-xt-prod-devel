require inc/agl-image.inc

IMAGE_INSTALL_append = " \
    pulseaudio \
    wayland-ivi-extension \
"

