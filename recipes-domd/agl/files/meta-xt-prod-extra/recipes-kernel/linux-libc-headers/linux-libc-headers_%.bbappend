RENESAS_BSP_URL = "git://github.com/xen-troops/linux.git"

BRANCH = "ces2018"
SRCREV = "${AUTOREV}"
