VSPFILTER_CONF_r8a7795 = "gstvspfilter-${@d.getVar('XT_CANONICAL_MACHINE_NAME', False)}_r8a7795.conf"
VSPFILTER_CONF_r8a7796 = "gstvspfilter-${@d.getVar('XT_CANONICAL_MACHINE_NAME', False)}_r8a7796.conf"

