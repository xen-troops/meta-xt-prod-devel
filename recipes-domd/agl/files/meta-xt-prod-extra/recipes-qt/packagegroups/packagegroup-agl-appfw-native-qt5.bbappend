# We do not want depend on dev packages
RDEPENDS_${PN}_remove = "\
    qtbase-dev \
    qtbase-staticdev \
"
