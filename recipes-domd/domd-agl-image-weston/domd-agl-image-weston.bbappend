require ../agl/inc/domd-agl-image.inc

